# IAR project ski_contriller_pcb_v6.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCIncludePath2: app\; board\; cc1101_lib\; modules\; sensors\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: LPC2148_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2142 NXP LPC2142
  ICCARM.CCIncludePath2: app\; board\; cc1101_lib\; modules\; sensors\; 
  group (top)
    app/: algoritm_beg.c main.cpp uart_service.cpp
  group cc1101
    cc1101_lib/: cc1101_bsp.c cc1101_drv.c
  group sensors
    sensors/: accel_drv.c hyro_drv.c
  group system
    board/: cpsr.s79 lpc2xxx_cstartup.s79
    modules/: crc.c LPC_Vic.c
