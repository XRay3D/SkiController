<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ski_contriller_pcb_v6.ewp</path>
  </project>
  <batchBuild/>
</workspace>


